# Keil uVision project drv_gpio_example.uvprojx, settings and files
target drv_gpio_example (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: drv_gpio_example +hex
  c flags: Optim=1
  c define: NRF52832
  c misc: --c99
  c include: ..\..\drv_gpio;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\libraries\util;..\..\..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../../: drv_gpio_example.c
    ../../drv_gpio/: drv_gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.14.1
